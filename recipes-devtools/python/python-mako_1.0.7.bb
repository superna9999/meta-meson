inherit setuptools
require recipes-devtools/python/python-mako.inc

BBCLASSEXTEND = "native"
