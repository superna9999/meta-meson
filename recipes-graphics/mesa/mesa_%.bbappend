PACKAGECONFIG:append:meson-gx = "kmsro lima panfrost"
