FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-libdrm-headers-Sync-with-drm-next.patch"

